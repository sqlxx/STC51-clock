# Keil uVision project 时钟.uvproj, settings and files
target 时钟 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group time
    ./: common.c clock.c digital.c DS1302.c DS18B20.c simpleKeyboard.c
